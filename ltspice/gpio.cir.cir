* C:\Users\Gowthami\Desktop\ltspice\GPIO with E=1.asc
R1 N002 PUEN 10K
R2 PDEN 0 10K
V1 EN 0 PWL(0m 1.8 9.9999m 1.8 10m 1.8 19.99990m 1.8 20m 1.8 29.9999m 1.8 30m 1.8 34.9999m 1.8 35m 1.8 39.9999m 1.8 40m 1.8 44.9999m 1.8 45m 1.8 49.9999m 1.8 50m 1.8 59.9999m 1.8 60m 1.8 69.9999m 1.8 70m 1.8 79.9999m 1.8 80m 0 89.9999m 0 90m 0 99.9999m 0)
V4 A 0 PWL(0m 0 9.9999m 0 10m 1.8 19.9999m 1.8 20m 1.8 29.9999m 1.8 30m 0 34.9999m 0 35m 1.8 39.9999m 1.8 40m 0 44.9999m 0 45m 1.8 49.9999m 1.8 50m 0 59.9999m 0 60m 1.8 69.9999m 1.8 70m 1.8 79.9999m 1.8 80m 0 89.9999m 0 90m 1.8 99.9999m 1.8)
V7 N001 0 1.8
R3 N006 0 10K
R4 N008 N007 10K
XX1 PDEN N010 inverter
XX3 PI Y PO nand
M5 Y N005 N003 N003 CMOSP l=180n w=900n m=1
M6 Y N005 0 0 CMOSN l=180n w=360n
M2 N005 N004 N003 N003 CMOSP l=180n w=900n m=1
M4 N005 N004 0 0 CMOSN l=180n w=360n
M7 PUEN N006 0 0 CMOSN l=180n w=360n
M8 N007 N008 PDEN PDEN CMOSN l=180n w=360n
M9 N009 PUEN N001 N001 CMOSN l=180n w=360n
M10 N009 N010 0 0 CMOSP l=180n w=900n m=1
XX2 A EN N004 tristate
V6 N003 0 1.8
V2 N002 0 PWL(0m 0 4.9999m 0 5m 1.8 9.9999m 1.8 10m 0 14.9999m 0 15m 1.8 19.9999m 1.8 20m 0 24.9999m 0 25m 1.8 29.9999m 1.8 30m 1.8 39.9999m 1.8 40m 1.8 49.9999m 1.8 50m 1.8 59.9999m 1.8 60m 0 69.9999m 0 70m 0 79.9999m 0)
V3 N007 0 PWL(0m 0 4.9999m 0 5m 1.8 9.9999m 1.8 10m 0 14.9999m 0 15m 1.8 19.9999m 1.8 20m 0 24.9999m 0 25m 1.8 29.9999m 1.8 30m 1.8 39.9999m 1.8 40m 1.8 49.9999m 1.8 50m 0 59.9999m 0 60m 1.8 69.9999m 1.8 70m 1.8 79.9999m 1.8)
V5 PI 0 PWL(0m 0 4.9999m 0 5m 1.8 9.9999m 1.8 10m 0 19.9999m 0 20m 1.8 29.9999m 1.8 30m 1.8 39.9999m 1.8 40m 0 49.9999m 0 50m 0 54.9999m 0 55m 1.8 59.9999m 1.8 60m 0 69.9999m 0 70m 1.8 79.9999m 1.8)

* block symbol definitions
.subckt inverter I O
V1 N001 0 1.8
M1 O I N001 N001 CMOSP l=180n w=900n m=1
M2 O I 0 0 CMOSN l=180n w=360n
.include PMOS-180nm.lib
.include NMOS-180nm.lib
.ends inverter

.subckt nand A B O
V1 N001 0 1.8
M1 O A N001 N001 CMOSP l=180n w=900n m=1
M2 O B N001 N001 CMOSP l=180n w=900n m=1
M3 N002 B 0 0 CMOSN l=180n w=360n
M4 O A N002 0 CMOSN l=180n w=360n
.include NMOS-180nm.lib
.include PMOS-180nm.lib
.ends nand

.subckt tristate I EN O
V1 N001 0 1.8
M1 N003 EN N004 N004 CMOSP l=180n w=900n m=1
M2 N005 EN N001 N001 CMOSP l=180n w=900n m=1
M5 N004 I N001 N002 CMOSP l=180n w=900n m=1
M3 N003 N005 N006 N006 CMOSN l=180n w=360n
M4 N006 I 0 N007 CMOSN l=180n w=360n
M6 N005 EN 0 0 CMOSN l=180n w=360n
M7 O N003 N001 N001 CMOSP l=180n w=900n m=1
M8 O N003 0 0 CMOSN l=180n w=360n
.include PMOS-180nm.lib
.include NMOS-180nm.lib
.ends tristate
.tran 1 100ms 0
.include PMOS-180nm.lib
.include NMOS-180nm.lib
* Tristate
* inverter
* NAND
*control
.control
run
plot V(EN) V(A)
plot V(PO) V(PI) V(Y)
.endc
.end
